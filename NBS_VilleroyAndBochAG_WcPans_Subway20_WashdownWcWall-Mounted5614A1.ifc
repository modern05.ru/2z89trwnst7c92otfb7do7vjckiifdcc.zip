Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-12-06T11:29:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Dec 06 11:29:09 2022* Host: NCL-PI16* Database: C:\Users\haye\AppData\Local\Temp\{2C095FB2-912E-42EE-A501-E261AA0D7244}\ifc* Database version: 5507* Database creation date: Tue Dec 06 11:29:08 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Dec 06 11:29:08 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Dec 06 11:29:08 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowTerminal: 5614A101, NBS_VilleroyAndBochAG_WcPans_Subway20_WashdownWcWall-Mounted5614A1:5614A101:436753
In: Level 0
Type - PredefinedType: TOILETPAN; Classification: Pr_40_20_93_94 (Uniclass2015); Material: NBS_VilleroyAndBoch_SanitaryCeramics_WhiteAlpin
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBochAG_WcPans_Subway20_WashdownWcWall-Mounted5614A101; ManufacturerName: Villeroy & Boch AG; ManufacturerURL: https://pro.villeroy-boch.com; NBSCertification: www.nationalbimlibrary.com/cert/wrqfrt1s; ProductInformation: https://pro.villeroy-boch.com/en/euo/bw/m/5614A1; Revision: 2; Uniclass2015Title: WC pans; Uniclass2015Code: Pr_40_20_93_94; Uniclass2015Version: Products v1.22; Version: 2
Type - NBS_Data - ContainsRedListMaterials: n/a; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; EmbodiedCarbon: n/a; Recyclability: n/a; RecycledContent: n/a; Standard: To BS EN 997; Form: Wall-mounted, washdown; ConnectingDimensions: n/a; MaterialsBody: Ceramic; MaterialsFinishAndColour: White; WaterSupplyOutletAndSeatHolesWaterSupply: Back inlet; WaterSupplyOutletAndSeatHolesOutlet: Horizontal; WaterSupplyOutletAndSeatHolesSeatHoles: n/a; IntegralAccessories: Seat (9M7461).,Toilet seat and cover (9M68Q1).,Toilet seat and cover SlimSeat (9M78S1).,Toilet seat and cover (9M68S1); Execution: n/a; Weight: 25.2 kg; Width: 370 mm; Depth: 560 mm
Type - IFC - IfcExportAs: IfcSanitaryTerminalType; IfcExportType: TOILETPAN
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_93_94:WC pans; CodePerformance: n/a; Color: White; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: marketing@villeroy-boch.co.uk; Material: Ceramic; ModelNumber: 5614A101; ModelReference: Subway20_WashdownWCWallMounted_5614A101; Name: WcPans_Subway20_WashdownWcWall-Mounted5614A101_VilleroyAndBochAG; NominalHeight: 415 mm; NominalLength: 560 mm; NominalWidth: 370 mm; ReplacementCost: n/a; Shape: Oval; Size: 370 x 560 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
